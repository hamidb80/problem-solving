# Keil uVision project Library.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Library +hex
  AfterMake: fromelf.exe --bin --output ./library.bin ./obj/library.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: .\Startup;C:\Keil\ARM\INC\NXP\LPC17xx;C:\Keil\ARM\CMSIS\Include;C:\Keil\ARM\RV31\INC
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./Startup/: system_LPC17xx.c startup_LPC17xx.s
  group Main
    ./: gpio.cpp main.cpp Uart.cpp Fifo.cpp Outoperator.cpp RTC.cpp Ssp.cpp SpiFlash.cpp USBHW.cpp usbdesc.cpp USBCore.cpp hiduser.cpp Spi.cpp WatchDog.cpp Timer.cpp SysTick.cpp
